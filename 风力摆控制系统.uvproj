# Keil uVision project 风力摆控制系统.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MOTOR +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user;.\CM3;.\Motor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./startup/: startup_stm32f10x_hd.s
  group USR
    ./user/: main.c usart1.c delay.c stm32f10x_it.c timer.c indkey.c mpu6050.c ahrs.c iic_analog.c LED.c usart2.c
    ./FWlib/SRC/: misc.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c
  group CMSYS
    ./CM3/: core_cm3.c system_stm32f10x.c
  group Motor
    ./Motor/: Motor_Control.c Motor_PWM.c Motor_PID.c
